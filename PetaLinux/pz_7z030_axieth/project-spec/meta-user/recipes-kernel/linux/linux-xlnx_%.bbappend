SRC_URI += "file://user.cfg \
            file://axieth.patch \
            file://user_2020-08-05-13-17-00.cfg \
            file://user_2020-08-05-13-39-00.cfg \
            file://user_2020-08-09-02-07-00.cfg \
            file://user_2020-08-16-22-29-00.cfg \
            file://user_2020-08-17-14-49-00.cfg \
            file://user_2020-08-17-15-19-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

